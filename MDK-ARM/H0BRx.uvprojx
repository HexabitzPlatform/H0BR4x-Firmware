# Keil uVision project H0BRx.uvprojx, settings and files
target Module 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F091CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Module 1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xB,H0BR4,_module=1
  c include: ..\User;..\H0BR4;..\BOS;..\Thirdparty\Middleware\FreeRTOS\Source\CMSIS_RTOS;..\Thirdparty\Middleware\FreeRTOS\Source\include;..\Thirdparty\Middleware\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\Thirdparty\STM32F0xx_HAL_Driver\Inc\Legacy;..\Thirdparty\STM32F0xx_HAL_Driver\Inc;..\Thirdparty\CMSIS\Device\ST\STM32F0xx\Include;..\Thirdparty\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ../User/: main.c
  group CMSIS
    ../thirdparty/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group STM32F0xx_HAL_Driver
    ../thirdparty/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c
    ../Thirdparty/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c
  group BITZ/BOS
    ../BOS/: BOS.c BOS_CLI.c BOS_eeprom.c BOS_freertos.c
  group BITZ/H0BR4
    ../H0BR4/: H0BR4.c H0BR4_dma.c H0BR4_gpio.c H0BR4_it.c H0BR4_uart.c startup_stm32f091xc.s H0BR4_i2c.c H0BR4_LSM6DS3_driver.c H0BR4_LSM303AGR_ACC_driver.c H0BR4_LSM303AGR_MAG_driver.c
  group FreeRTOS
    ../thirdparty/Middleware/FreeRTOS/Source/: croutine.c event_groups.c FreeRTOS_CLI.c list.c queue.c tasks.c timers.c
    ../thirdparty/Middleware/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../thirdparty/Middleware/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../thirdparty/Middleware/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
